# Keil uVision project VFDMatrix.uvproj, settings and files
target VFDMatrix (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: VFDMatrix +hex
  c flags: Optimize=8 SizeSpeed=1
  group src_code
    ./: GP1247AI.cpp main.cpp
